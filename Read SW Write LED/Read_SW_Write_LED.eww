<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Read_SW_Write_LED.ewp</path>
    </project>
    <batchBuild />
</workspace>
